SKINNAME = "Turbo"

require raed-skins.inc
require skin-python.inc
