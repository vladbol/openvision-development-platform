MODULE = "PermanentVfdClock"
DESCRIPTION = "Show clock in VFD permanently"

require conf/license/license-gplv2.inc
require openplugins-replace-pli.inc
require openplugins-distutils.inc
