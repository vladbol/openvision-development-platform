RDEPENDS_packagegroup-base-bluetooth = "\
    bluez5 \
    "
