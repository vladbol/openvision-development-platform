SRC_URI = "git://github.com/OpenVuPlus/dvbapp.git;protocol=http;branch=${BRANCH} \
        file://move-youtube-menu-entry.patch \
"
